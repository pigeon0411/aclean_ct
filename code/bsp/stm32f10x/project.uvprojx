# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eb120 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;applications;drivers;.\FreeModbus;.\FreeModbus\port;.\FreeModbus\port\rtt;.\FreeModbus\modbus\rtu;.\FreeModbus\modbus\include;.\FreeModbus\modbus\functions;..\..\components\drivers;..\..\components\drivers\include\drivers;.\applications\miotlink;.\FreeModbus_2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
    ./applications/: api.c malloc.c
    ./applications/miotlink/: wifi_mod_uart.c
    ./drivers/: bsp.c
  group Drivers
    drivers/: board.c stm32f10x_it.c usart.c
    ./drivers/: gpio.c bsp_spi_flash.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/misc/: pin.c
  group Components
    ../../components/init/: components.c
  group freemod bus
    ./FreeModbus/modbus/: mb.c mb_m.c
    ./FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
    ./FreeModbus/modbus/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ./FreeModbus/port/: user_mb_app.c user_mb_app_m.c
    ./FreeModbus/port/rtt/: port.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c
  group modbus_2
    ./FreeModbus_2/: mbcrc_2.c mbfunccoils_2.c mbfunccoils_m_2.c mbfuncdiag_2.c mbfuncdisc_2.c mbfuncdisc_m_2.c mbfuncholding_2.c mbfuncholding_m_2.c mbfuncinput_2.c mbfuncinput_m_2.c mbfuncother_2.c mbrtu_2.c mbrtu_m_2.c mbutils_2.c port_2.c portevent_2.c portevent_m_2.c portserial_2.c portserial_m_2.c porttimer_2.c porttimer_m_2.c user_mb_app_2.c user_mb_app_m_2.c mb_m_2.c disp_board.c
