# Keil uVision project FreeModbus_Slave&Master+RTT+STM32.uvprojx, settings and files
target STM32F103ZET6_FLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BX_GeneralProgram
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.0.0\include;..\RT-Thread-1.0.0\libcpu\arm\stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/src/: app.c app_task.c stm32f10x_it.c
    ../APP/inc/: delay_conf.h stm32f10x_conf.h rtconfig.h
  group BSP
    ../BSP/src/: bsp.c usart.c gpio.c
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group StdPeriph_Driver
    ../Libaries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libaries/CMSIS_MDK/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libaries/CMSIS_MDK/CM3/CoreSupport/: core_cm3.c
    ../Libaries/CMSIS_MDK/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RT-Thread Kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread Drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
    ../RT-Thread-1.2.2/components/drivers/misc/: pin.c
  group FreeModbusMaster
    ../FreeModbus/modbus/: mb_m.c
    ../FreeModbus/modbus/rtu/: mbrtu_m.c mbcrc.c
    ../FreeModbus/modbus/functions/: mbfuncholding_m.c mbfunccoils_m.c mbfuncinput_m.c mbfuncdisc_m.c mbutils.c mbfuncother.c
    ../FreeModbus/port/rtt/: portevent_m.c portserial_m.c porttimer_m.c port.c
    ../FreeModbus/port/: user_mb_app_m.c
  group application
    ../applications/: rs485_decode.c
    ../applications/miotlink/: wifi_mod_uart.c
target STM32F103CBT6_FLASH (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: airclean
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.2.2\include;..\RT-Thread-1.2.2\components\drivers\include;..\RT-Thread-1.2.2\components\drivers\include\drivers;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\port;..\applications;..\applications\miotlink
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 4.1.0
